# Keil uVision project imxrt106xflashloader.uvprojx, settings and files
target Cortex-M (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.10.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt1060flashloader
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1061CVL5A,SKIP_SYSCLK_INIT,NDEBUG
  c include: .\drivers;d:\imxrt1061flashloader
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group drivers
    ./drivers/: system_MIMXRT1061.c flexspi_nor.c board.c clock_config.c fsl_clock.c fsl_common.c pin_mux.c fsl_flexspi.c
